# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp_stm32f4xx\inc;..\..\User\bsp_stm32f4xx;..\..\User;..\..\User\FatFS\src;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\User\usbh_mass_storage;..\..\User\bsp_stm32f4xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c demo_mp3_player.c
  group BSP
    ../../User/bsp_stm32f4xx/src/: bsp_timer.c bsp_vs1053b.c bsp_usart.c bsp_rng.c bsp_led.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c stm32f4xx_assert.c bsp.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_rng.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group FatFS
    ../../User/FatFS/src/: diskio.c ff.c
    ../../User/FatFS/src/option/: cc936.c
  group USB_Mass_Storage
    ../../User/usbh_mass_storage/: usb_bsp.c usbh_it.c usbh_usr.c usbh_bsp_msc.h
  group USB_HOST
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: as above
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp_stm32f4xx\inc;..\..\User\bsp_stm32f4xx;..\..\User;..\..\User\FatFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
